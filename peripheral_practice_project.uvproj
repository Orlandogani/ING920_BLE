# Keil uVision project peripheral_practice_project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING2000 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x2000000-0x2200000) IRAM(0x20000000-0x20008000)
  output: peripheral_practice_project +hex
  AfterMake: fromelf.exe --bin -o peripheral_practice_project.bin ./output/peripheral_practice_project.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/inc;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/inc/os;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/BSP;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/StartUP/ing20;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/Tools;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src
  library: MicroLIB
  memory RVCT4: ROM 33738752 size 339968
  memory RVCT9: RAM 536892192 size 19680
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing2000.s
    C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/ING208xx/: symdefs.m
  group BSP
    C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/BSP/: eflash.c
  group FWlib
    C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_asdm.c peripheral_dma.c peripheral_i2s.c peripheral_keyscan.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
