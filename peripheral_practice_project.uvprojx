# Keil uVision project peripheral_practice_project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING2000 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M3") CLOCK(12800000) ELITTLE
  output: peripheral_practice_project +hex
  AfterMake: fromelf.exe --bin -o peripheral_practice_project.bin ./output/peripheral_practice_project.axf
  AfterMake: fromelf.exe --bin ./output/peripheral_practice_project.axf --output ./output/peripheral_practice_project.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/inc;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/inc/os;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/BSP;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/StartUP/ing20;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/Tools;C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x202d000 size 0x53000
  memory RVCT9: RAM 0x20005320 size 0x4ce0
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing2000.s
    C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/typical/ING208xx/: symdefs.m
  group BSP
    C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/BSP/: eflash.c
  group FWlib
    C:/Users/roiki/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_asdm.c peripheral_dma.c peripheral_i2s.c peripheral_keyscan.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ./: rf_util.c
  group XboxOneModules
    ./: xb1_data_lib.h
  group XBlib
    ./: xb1_drv_adc.h xb1_drv_adc.c
software components: CMSIS:CORE 4.3.0
